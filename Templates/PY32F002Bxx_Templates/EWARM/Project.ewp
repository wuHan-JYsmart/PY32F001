# IAR project Project.ewp, settings and files
configuration PY32F002Bx5_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F002Bx5 Puya PY32F002Bx5
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F002Bx5
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F002B_HAL_Driver\Inc; ..\Inc; ..\exitGroup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f002bx5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32f002b.c
  group Drivers/PY32F002B_HAL_Driver
    ../../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c py32f002b_ll_adc.c py32f002b_ll_comp.c py32f002b_ll_crc.c py32f002b_ll_exti.c py32f002b_ll_gpio.c py32f002b_ll_i2c.c py32f002b_ll_lptim.c py32f002b_ll_pwr.c py32f002b_ll_rcc.c py32f002b_ll_spi.c py32f002b_ll_tim.c py32f002b_ll_usart.c
  group Example/EWARM
    ./: startup_py32f002bxx.s
  group Example/User
    ../Src/: main.c mPowerBusApp.c mWS2812.c py32f002b_hal_msp.c py32f002b_it.c
  group exitGroup
    ../exitGroup/: eAdcDriver.c eFlashOpt.c eGpioNvic.c eGpioOutput.c ePwm1Driver.c eSpi1Driver.c eTim6BaseDriver.c eUsart1Driver.c
